# IAR project programmable feedback control.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F4XX_VG; USE_STDPERIPH_DRIVER; HSE=8000000; USE_STM32F4_DISCOVERY; USE_USB_OTG_FS
  ICCARM.CCIncludePath2: CMSIS\ST\STM32F4xx\Include; ; STM32F4xx_StdPeriph_Driver\inc; Utilities\STM32F4-Discovery; Application; Utilities\FatFs_vR0.08a; STM32_USB_Device_Library\Class\cdc\inc; STM32_USB_Device_Library\Core\inc; STM32_USB_OTG_Driver\inc; test_section\; test_section\driver_testing
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: programmable feedback control.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group _test_section/driver_testing
    test_section/driver_testing/: test_DAC_LTC1661_driver.c test_GLCD5110_driver.c test_MCP3202_driver.c test_oxygen_sensor_driver.c
  group _test_section/opm
    test_section/: opm.c
  group _test_section/test_oxygen_pulse_meter
    test_section/: opm_test.c
  group _test_section/test_oxygen_sensor
    test_section/: test_oxygen_sensor.c
  group FAT_FS
    Utilities/FatFs_vR0.08a/: diskio.c ff.c
  group STD_PERIPH_DRIVER
    STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group STM32_USB_Device_Library
    Application/: usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
    STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
    STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group STM32_USB_OTG_Driver
    STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group STM32F4 Discovery
    Utilities/STM32F4-Discovery/: stm32f4_discovery.c stm32f4_discovery_sdio_sd.c
  group System_conf
    ./: startup_stm32f4xx.s system_stm32f4xx.c
  group User
    Application/: Connect_GUI.c Control_valve.c DAC_LTC1661.c GLCD5110.c MCP3202.c Oxygen_Pulse_Meter.c Oxygen_sensor.c system_init.c testControlValve.c
    ./: main.c stm32f4xx_it.c
  group User/Control model v1
    Application/: alarm_condition_previous_version.c check_status_previous_version.c
  group User/Control model v2
    Application/: alarm_condition.c check_status_profile.c
  group User/Control model v3
    Application/: alarm_condition_v3.c check_status_profile_v3.c
